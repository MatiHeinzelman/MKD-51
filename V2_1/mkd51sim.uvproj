# Keil uVision project mkd51sim.uvproj, settings and files
target Symulator MKD51 (MCS-51)
  device: 87C51 Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: mkd51sim
  c flags: Optimize=8 SizeSpeed=1
  group Zrodla
    ./: lcd.c main.c assembly.a51 main.h
target MKD51 (MCS-51)
  device: 87C51 Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: mkd51sim +hex
  c flags: Optimize=8 SizeSpeed=1
